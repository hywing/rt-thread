# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa153 (6190000::V6.19::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: IRAM(0x20000000,0x6000) IRAM2(0x04000000,0x2000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x020000) XRAM(0x04002000,0x1000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: DEBUG, CPU_MCXA153VLH, RT_USING_ARMLIBC, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\drivers\include;..\Libraries\drivers\config;board\MCUX_Config\board;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\drivers\spi;..\Libraries\MCXA153\middleware\sdmmc\port;..\Libraries\MCXA153\middleware\sdmmc\inc;..\Libraries\MCXA153\components\codec;..\..\..\..\..\components\drivers\include;..\Libraries\MCXA153\MCXA153;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\utilities\ulog;..\..\..\..\..\components\finsh;applications;..\..\..\..\..\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\Libraries\CMSIS\Core\Include;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\include;..\Libraries\MCXA153\MCXA153\drivers;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\drivers\include;..\Libraries\drivers;board;..\..\..\..\..\components\libc\posix\ipc;.
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x4000000 size 0x2000
  scatter file: .\board\linker_scripts\MCXA153_flash.scf
  group Applications
    applications/: lcd.c main.c lcd_init.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../../../components/drivers/pin/: pin.c
    ../../../../../components/drivers/serial/: serial.c
    ../../../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_pwm.c drv_spi.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh.c msh_parse.c cmd.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/MCXA153/MCXA153/drivers/: fsl_ctimer.c fsl_erm.c fsl_lpuart.c fsl_freqme.c fsl_common_arm.c fsl_wwdt.c fsl_reset.c fsl_spc.c fsl_edma.c fsl_i3c_edma.c fsl_vbat.c fsl_utick.c fsl_edma_soc.c fsl_lptmr.c fsl_gpio.c fsl_lpcmp.c fsl_lpuart_edma.c fsl_ostimer.c fsl_lpi2c_edma.c fsl_aoi.c fsl_inputmux.c fsl_clock.c fsl_common.c fsl_eqdc.c fsl_glikey.c fsl_wuu.c fsl_cmc.c fsl_lpi2c.c fsl_eim.c fsl_pwm.c fsl_waketimer.c fsl_lpadc.c fsl_i3c.c fsl_crc.c fsl_lpspi.c fsl_lpspi_edma.c
    ../Libraries/MCXA153/MCXA153/arm/: startup_MCXA153.s
    ../Libraries/MCXA153/MCXA153/: system_MCXA153.c
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
